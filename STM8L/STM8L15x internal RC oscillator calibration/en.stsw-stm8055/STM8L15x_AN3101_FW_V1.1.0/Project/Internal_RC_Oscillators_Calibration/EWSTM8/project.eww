<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm8l1526-eval.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stm8l1528-eval.ewp</path>
  </project>
  <batchBuild/>
</workspace>


