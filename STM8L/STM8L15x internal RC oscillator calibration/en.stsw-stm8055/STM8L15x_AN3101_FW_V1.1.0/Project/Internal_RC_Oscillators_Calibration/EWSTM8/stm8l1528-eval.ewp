# IAR project stm8l1528-eval.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1528_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8l1528-eval.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group STM8_EVAL
    ../../../Utilities/STM8_EVAL/: stm8_eval.c
    ../../../Utilities/STM8_EVAL/Common/: stm8_eval_lcd.c
  group STM8L15x_StdPeriph_Driver
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_beep.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_usart.c
  group User
    ../src/: hsi_calibration.c lsi_measurement.c main.c stm8l15x_it.c
